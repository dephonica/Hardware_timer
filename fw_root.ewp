# IAR project fw_root.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x400
  ICCSTM8.CCIncludePath2: Libraries\STM8_TouchSensing_Driver\inc; Libraries\STM8S_StdPeriph_Driver\inc; Project\Discover\inc
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: fw_root.hex
  ILINK.IlinkOutputFile: fw_root.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp
